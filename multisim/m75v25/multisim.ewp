# IAR project multisim.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: \multisim.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: 
  AARM.ADefines: SGOLD75
  postbuild: ..\elf2vkp Release\Exe\multisim.elf multisim.vkp c:\temp\sk_full.bin
  XLINK.XclFile: .\multisim.xcl
  group (top)
    ./: multisim.xcl
  group emulator
    ../shared/: a3a8.c sim_access.c
  group menu
    ../shared/: menu.c
  group Startup
    ../shared/: MyStart.s
