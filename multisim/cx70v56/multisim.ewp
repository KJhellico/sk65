# IAR project multisim.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: ..\elf2vkp Release\Exe\multisim.elf multisim.vkp f:\cx70v56\cx70v56.bin
  XLINK.XclFile: .\multisim.xcl
  group (top)
    ./: multisim.xcl
  group emulator
    ../shared/: a3a8.c file.c sim_access.c
  group menu
    ../shared/: menu.c
  group Startup
    ../shared/: MyStart.s
