# IAR project multisim.ewp, settings and files
configuration SK65v50 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: ..\elf2vkp SK65v50\Exe\multisim.elf vkp\sk65v50_multisim.vkp c:\temp\sk_full.bin
  XLINK.XclFile: .\SK65v50.xcl
configuration M75v25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: X75
  postbuild: ..\elf2vkp M75v25\Exe\multisim.elf vkp\m75v25_multisim.vkp c:\temp\sk_full.bin
  XLINK.XclFile: .\M75v25.xcl
configuration C75v22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: X75
  postbuild: ..\elf2vkp C75v22\Exe\multisim.elf vkp\c75v22_multisim.vkp f:\c75v22\c75v22.bin
  XLINK.XclFile: .\C75v22.xcl
configuration CX70v56 (ARM)
  as the first configuration, except:
  postbuild: ..\elf2vkp CX70v56\Exe\multisim.elf vkp\cx70v56_multisim.vkp f:\cx70v56\cx70v56.bin
  XLINK.XclFile: .\CX70v56.xcl
  group (top)
    ./: C75v22.asm C75v22.xcl CX70v56.asm CX70v56.xcl M75v25.asm M75v25.xcl SK65v50.asm SK65v50.xcl
  group emulator
    ./: a3a8.c file.c sim_access.c
  group menu
    ./: menu.c
  group Startup
    ./: Start.asm
